<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tw_1</value></param>
<param><key>author</key><value>Daniel Estevez</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Flowgraph to test the TW-1 decoder</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>TW-1 test decoder</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_mu</value></param>
<param><key>value</key><value>0.175*3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>ax100_gomx3_rs_decode</key>
<param><key>id</key><value>ax100_gomx3_rs_decode_0</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>c</key><value>1/8.0</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>tw-1c.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>csp_print_header</key>
<param><key>id</key><value>csp_print_header_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>gain_mu</value></param>
<param><key>gain_omega</key><value>0.25*gain_mu*gain_mu</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>samp_per_sym*(1+0.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_bb</key>
<param><key>id</key><value>digital_correlate_access_code_tag_bb_0</value></param>
<param><key>access_code</key><value>10010011000010110101000111011110</value></param>
<param><key>tagname</key><value>syncword</value></param>
<param><key>threshold</key><value>4</value></param>
</block>
<block>
<key>digital_descrambler_bb</key>
<param><key>id</key><value>digital_descrambler_bb_0</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0x00</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>2400</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>2000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>synctags_fixedlen_tagger</key>
<param><key>id</key><value>synctags_fixedlen_tagger_0</value></param>
<param><key>packetlen_tag</key><value>packet_len</value></param>
<param><key>packet_len</key><value>256*8</value></param>
<param><key>stream_type</key><value>byte</value></param>
<param><key>syncword_tag</key><value>syncword</value></param>
</block>
<connection><source_block_id>ax100_gomx3_rs_decode_0</source_block_id><sink_block_id>blocks_message_debug_1</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>ax100_gomx3_rs_decode_0</source_block_id><sink_block_id>csp_print_header_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>ax100_gomx3_rs_decode_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>digital_descrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0</source_block_id><sink_block_id>synctags_fixedlen_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>synctags_fixedlen_tagger_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
